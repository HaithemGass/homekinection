# IAR project RCB212.ewp, settings and files
configuration All_Rcb_Atmega1281_Rf212_8Mhz (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD_RCB; ATMEGA1281; HAL_8MHz; AT86RF212; RCB212_V532; NO_SECURITY_MODE; STACK_TYPE_ALL
  ICCAVR.CCDiagSuppress: Pa050, Pe188
  ICCAVR.newCCIncludePaths: ..; ../include; ../../../BitCloud/Components/BSP/RCB/include; ../../../BitCloud/lib; ../../../BitCloud/Components/HAL/include; ../../../BitCloud/Components/BSP; ../../../BitCloud/Components/BSP/include; ../../../BitCloud/Components/NWK/include; ../../../BitCloud/Components/NWK/include/private; ../../../BitCloud/Components/ZDO/include; ../../../BitCloud/Components/ZDO/include/private; ../../../BitCloud/Components/APS/include; ../../../BitCloud/Components/APS/include/private; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/Components/ConfigServer/include; ../../../BitCloud/Components/ConfigServer/include/private; ../../../BitCloud/Components/PersistDataServer/include; ../../../BitCloud/Components/PersistDataServer/include/private; ../../../BitCloud/Components/Security/TrustCentre/include; ../../../BitCloud/Components/Security/ServiceProvider/include; ../../../BitCloud/Components/HAL/avr/atmega1281/common/include; ../../../BitCloud/Components/HAL/avr/atmega1281/rcb231_212/include; ../../../BitCloud/Components/MAC_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_ENV/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWI/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/RF231_RF212/PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/RF231_RF212/MAC_HWD/include
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICCAVR.PreInclude: MakerulesBc_All_Atmega1281_Rf212_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm1281bitcloud.xcl; ../../../BitCloud/lib/libHAL_Rcb231_212_Atmega1281_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_All_Atmega1281_Rf212_Iar.a; ../../../BitCloud/lib/WdtInitatmega1281_Iar.o
configuration Coordinator_Rcb_Atmega1281_Rf212_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_RCB; ATMEGA1281; HAL_8MHz; AT86RF212; RCB212_V532; NO_SECURITY_MODE; STACK_TYPE_COORDINATOR
  ICCAVR.PreInclude: MakerulesBc_Coordinator_Atmega1281_Rf212_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm1281bitcloud.xcl; ../../../BitCloud/lib/libHAL_Rcb231_212_Atmega1281_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_Coordinator_Atmega1281_Rf212_Iar.a; ../../../BitCloud/lib/WdtInitatmega1281_Iar.o
configuration Router_Rcb_Atmega1281_Rf212_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_RCB; ATMEGA1281; HAL_8MHz; AT86RF212; RCB212_V532; NO_SECURITY_MODE; STACK_TYPE_ROUTER
  ICCAVR.PreInclude: MakerulesBc_Router_Atmega1281_Rf212_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm1281bitcloud.xcl; ../../../BitCloud/lib/libHAL_Rcb231_212_Atmega1281_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_Router_Atmega1281_Rf212_Iar.a; ../../../BitCloud/lib/WdtInitatmega1281_Iar.o
configuration EndDevice_Rcb_Atmega1281_Rf212_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_RCB; ATMEGA1281; HAL_8MHz; AT86RF212; RCB212_V532; NO_SECURITY_MODE; STACK_TYPE_ENDDEVICE
  ICCAVR.PreInclude: MakerulesBc_EndDevice_Atmega1281_Rf212_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm1281bitcloud.xcl; ../../../BitCloud/lib/libHAL_Rcb231_212_Atmega1281_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_EndDevice_Atmega1281_Rf212_Iar.a; ../../../BitCloud/lib/WdtInitatmega1281_Iar.o
configuration All_Sec_Rcb_Atmega1281_Rf212_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_RCB; ATMEGA1281; HAL_8MHz; AT86RF212; RCB212_V532; STANDARD_SECURITY_MODE; STACK_TYPE_ALL
  ICCAVR.PreInclude: MakerulesBc_All_Sec_Atmega1281_Rf212_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm1281bitcloud.xcl; ../../../BitCloud/lib/libHAL_Rcb231_212_Atmega1281_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_All_Sec_Atmega1281_Rf212_Iar.a; ../../../BitCloud/lib/WdtInitatmega1281_Iar.o
configuration Coordinator_Sec_Rcb_Atmega1281_Rf212_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_RCB; ATMEGA1281; HAL_8MHz; AT86RF212; RCB212_V532; STANDARD_SECURITY_MODE; STACK_TYPE_COORDINATOR
  ICCAVR.PreInclude: MakerulesBc_Coordinator_Sec_Atmega1281_Rf212_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm1281bitcloud.xcl; ../../../BitCloud/lib/libHAL_Rcb231_212_Atmega1281_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_Coordinator_Sec_Atmega1281_Rf212_Iar.a; ../../../BitCloud/lib/WdtInitatmega1281_Iar.o
configuration Router_Sec_Rcb_Atmega1281_Rf212_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_RCB; ATMEGA1281; HAL_8MHz; AT86RF212; RCB212_V532; STANDARD_SECURITY_MODE; STACK_TYPE_ROUTER
  ICCAVR.PreInclude: MakerulesBc_Router_Sec_Atmega1281_Rf212_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm1281bitcloud.xcl; ../../../BitCloud/lib/libHAL_Rcb231_212_Atmega1281_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_Router_Sec_Atmega1281_Rf212_Iar.a; ../../../BitCloud/lib/WdtInitatmega1281_Iar.o
configuration EndDevice_Sec_Rcb_Atmega1281_Rf212_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BOARD_RCB; ATMEGA1281; HAL_8MHz; AT86RF212; RCB212_V532; STANDARD_SECURITY_MODE; STACK_TYPE_ENDDEVICE
  ICCAVR.PreInclude: MakerulesBc_EndDevice_Sec_Atmega1281_Rf212_Iar.h
  XLINK.XExtraOptions: -f ../linkerScr/cfgm1281bitcloud.xcl; ../../../BitCloud/lib/libHAL_Rcb231_212_Atmega1281_8Mhz_Iar.a; ../../../BitCloud/lib/libBc_EndDevice_Sec_Atmega1281_Rf212_Iar.a; ../../../BitCloud/lib/WdtInitatmega1281_Iar.o
  group src
    ../src/: blink.c
  group include
    ../include/: blink.h
  group configuration
    ../: configuration.h
  group Components/PersistDataServer/src
    ../../../BitCloud/Components/PersistDataServer/src/: pdsWriteData.c pdsDataServer.c pdsCrcService.c
  group Components/Components/BSP/src
    ../../../BitCloud/Components/BSP/RCB/src/: leds.c bspTaskManager.c buttons.c fakeBSP.c
  group Components/ConfigServer/src
    ../../../BitCloud/Components/ConfigServer/src/: csPersistentMem.c csMem.c configServer.c
